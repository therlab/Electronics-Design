# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ../;C:\ti\mspm0_sdk_2_11_00_07\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_11_00_07\source;..\myused;..\BSP\JY61P_IIC;..\BSP\OLED_NEW;..\BSP\MOTOR;..\BSP\PID;..\BSP\grayscale;..\BSP\ENCODER;..\BSP\ZIGBEE;..\BSP\CONTROL;..\BSP\FLASH;..\myused
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_11_00_07\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c config.h empty.c
    ./: startup_mspm0g350x_uvision.s
  group myused
    ../myused/: uart.c uart.h tim.c tim.h fun.c fun.h usart_openmv.c usart_openmv.h
  group BSP
    ../BSP/MOTOR/: bsp_tb6612.c bsp_tb6612.h
    ../BSP/JY61P_IIC/: bsp_gyro.c bsp_gyro.h
    ../BSP/PID/: pid.c pid.h
    ../BSP/OLED_NEW/: oled_hardware_i2c.c oled_hardware_i2c.h oledfont.h
    ../BSP/ZIGBEE/: bsp_zigbee.c bsp_zigbee.h
    ../BSP/CONTROL/: bsp_control.c bsp_control.h
  group grayscale
    ../BSP/grayscale/: delay.c delay.h
    ../BSP/FLASH/: w25q64.c
  group ENCODER
    ../BSP/ENCODER/: encoder.c encoder.h
